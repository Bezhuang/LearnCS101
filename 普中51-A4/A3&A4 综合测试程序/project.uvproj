# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c key.c public.c led.c time.c beep.c smg.c leddz.c zlmoto.c bjmoto.c eeprom.c ds18b20.c ds1302.c xpt2046.c dac.c hwjs.c lcd1602.c
